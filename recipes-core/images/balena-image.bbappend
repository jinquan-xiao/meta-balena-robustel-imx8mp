include balena-image.inc

BALENA_BOOT_PARTITION_FILES = "imx-boot-${MACHINE}-sd.bin-flash_evk:/imx-boot.bin"
