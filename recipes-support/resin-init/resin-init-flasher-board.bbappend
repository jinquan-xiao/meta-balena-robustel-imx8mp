FILESEXTRAPATHS:append := "${THISDIR}/${PN}-imx8mp"
